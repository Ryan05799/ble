# Keil uVision project ble_app_uart.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_uart +hex
  c flags: Optim=1 wLevel=2
  c define: BOARD_NRF6310 NRF51,DEBUG_NRF_USER, NRF51822_QFAA_C0
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\ble\softdevice;..\sd_filesystem_src
  memory RVCT4: ROM 0x14000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ./../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ./../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
    ../: ble_init.c mpu_config.c sdcard_manage.c
  group Services
    ../../../../../Source/ble/ble_services/: ble_srv_common.c ble_bas.c
    ../: ble_mps.c
  group Libraries
    ../../../../../Source/ble/: ble_error_log.c ble_flash.c ble_advdata.c ble_conn_params.c ble_stack_handler.c ble_debug_assert_handler.c
    ../../../../../Source/app_common/: app_timer.c
    ../: nrf_adc.c
    ../../../../../Source/twi_master/: twi_sw_master.c
    ../../../../../Source/nrf_delay/: nrf_delay.c
    ../sd_filesystem_src/: diskio.c fattime.c ff.c
    ../../../../../Source/spi_master/: spi_master.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic
  cpu: as above
  output: ble_app_uart +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\ble\softdevice
  memory RVCT4: ROM 0x14000 size 0xc000
  memory RVCT9: RAM 0x20002000 size 0x2000
